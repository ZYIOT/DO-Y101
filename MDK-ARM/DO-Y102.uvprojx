# Keil uVision project DO-Y102.uvprojx, settings and files
target DO-Y102 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DO-Y103_APP +hex
  BeforeMake: .\DO-Y102\before_keil.bat
  AfterMake: fromelf --bin --output  .\DO-Y103\DO-Y103_APP.bin  .\DO-Y102\DO-Y103_APP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\APP;..\BSP;..\Common;..\MODBUS;..\STM32F10x_DSP_Lib\inc;..\Hardware
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Common
    ../Common/: utils.c mean_filter.c kalman_filter.c iap.c bootloader.c dwt_delay.c md5.c
  group BSP
    ../BSP/: bsp_dac.c bsp_wdg.c bsp_adc.c bsp_usart.c bsp_log.c bsp_mcu.c bsp_modbus.c bsp_flash.c bsp_adc_dev.c bsp_gpio.c
  group APP
    ../APP/: app.c app_task.c app_adc.c app_config.c app_do.c app_modbus.c app_mbedtls.c app_temperature.c
  group MODBUS
    ../MODBUS/: modbus_message.c modbus_buffer.c modbus_packet.c modbus_slave.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c dma.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_i2s.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group STM32F10x_DSP_Lib
    ../STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
    ../STM32F10x_DSP_Lib/src/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s
  group Hardware
    ../Hardware/ADC/: ltc2450.c
    ../Hardware/IIC/: gpio_iic.c
software components: CMSIS:CORE 4.3.0
