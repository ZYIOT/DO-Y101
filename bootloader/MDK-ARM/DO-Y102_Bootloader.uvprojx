# Keil uVision project DO-Y102_Bootloader.uvprojx, settings and files
target DO-Y103_Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DO-Y103_Bootloader +hex
  AfterMake: fromelf --bin --output  .\DO-Y103_Bootloader\DO-Y103_Bootloader.bin  .\DO-Y102_Bootloader\DO-Y103_Bootloader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc; ../../Drivers/STM32F1xx_HAL_Driver/Inc; ../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../../Drivers/CMSIS/Include; ../../Common; ../APP; ../BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1b000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group APP
    ../APP/: app.c xmodem.c
  group BSP
    ../BSP/: bsp_usart.c bsp_xmodem.c bsp_mcu.c bsp_log.c bsp_wdg.c
  group Common
    ../../Common/: iap.c ringbuffer.c bootloader.c utils.c md5.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
